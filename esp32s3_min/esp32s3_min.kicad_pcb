# Repository RraionWang/pcb_layout

## KiCad design esp32s3_min/esp32s3_min.kicad_pcb

Parts:
AE2: CA-C03
C1: 10pf; C_0402_1005Metric
C2: 10pF; C_0402_1005Metric
C3, C9, C10, C12, C16: 0.1uf; C_0402_1005Metric
C4, C5, C8: 1uf; C_0402_1005Metric
C6: 10nf; C_0402_1005Metric
C7, C11, C15, C18: 10uf; C_0402_1005Metric
C17, C19: 100nf; C_0402_1005Metric
D1: ESD; D_SOD-523
D3: LED; LED_0402_1005Metric
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_G-Switch_GT-USB-7010ASV
J2, J3: Conn_01x20_Pin; PinHeader_1x20_P1.27mm_Vertical
L1: 24nH; L_0402_1005Metric
L2: 2.0nh/500ma; L_0402_1005Metric
L3: 3nh; L_0402_1005Metric
R1, R2, R3, R4, R5, R12, R13: 0R; R_0402_1005Metric
R6: 499R; R_0402_1005Metric
R7, R8, R11: 5.1K; R_0402_1005Metric
R9, R10: 10K; R_0402_1005Metric
SW1, SW3: SW-SMD_L3.9-W3.6-LS4.8-EH
U1: ESP32-S3; QFN-56-1EP_7x7mm_P0.4mm_EP5.6x5.6mm
U3: W25Q16JVSS; WSON-8-1EP_8x6mm_P1.27mm_EP3.4x4.3mm
U4: ME6217C33M5G; SOT-23-5
Y1: 40MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
5V: C18.1, C19.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J2.14, J2.15, U4.1 (VIN), U4.3 (CE)
/BOOT: R10.1, SW1.2, U1.5 (GPIO0/BOOT)
/GPIO1: J3.1, U1.6 (GPIO1/ADC1_CH0)
/GPIO2: J3.2, U1.7 (GPIO2/ADC1_CH1)
/GPIO3: J3.3, U1.8 (GPIO3/ADC1_CH2)
/GPIO4: J3.4, U1.9 (GPIO4/ADC1_CH3)
/GPIO5: J3.5, U1.10 (GPIO5/ADC1_CH4)
/GPIO6: J3.6, U1.11 (GPIO6/ADC1_CH5)
/GPIO7: J3.7, U1.12 (GPIO7/ADC1_CH6)
/GPIO8: J3.8, U1.13 (GPIO8/ADC1_CH7)
/GPIO9: J3.9, U1.14 (GPIO9/ADC1_CH8)
/GPIO10: J3.10, U1.15 (GPIO10/ADC1_CH9)
/GPIO11: J3.11, U1.16 (GPIO11/ADC2_CH0)
/GPIO12: J3.12, U1.17 (GPIO12/ADC2_CH1)
/GPIO13: J3.13, U1.18 (GPIO13/ADC2_CH2)
/GPIO14: J3.14, U1.19 (GPIO14/ADC2_CH3)
/GPIO15: U1.21 (GPIO15/ADC2_CH4/XTAL_32K_P)
/GPIO16: U1.22 (GPIO16/ADC2_CH5/XTAL_32K_N)
/GPIO17: J3.15, U1.23 (GPIO17/ADC2_CH6)
/GPIO18: J3.16, U1.24 (GPIO18/ADC2_CH7)
/GPIO21: J3.17, U1.27 (GPIO21)
/GPIO33: J2.5, U1.38 (GPIO33)
/GPIO34: J2.6, U1.39 (GPIO34)
/GPIO35: J2.7, U1.40 (GPIO35)
/GPIO36: J2.8, U1.41 (GPIO36)
/GPIO37: J2.9, U1.42 (GPIO37)
/GPIO38: J3.18, U1.43 (GPIO38)
/GPIO39: J2.1, U1.44 (MTCK/JTAG/GPIO39)
/GPIO40: J2.2, U1.45 (MTDO/JTAG/GPIO40)
/GPIO41: J2.3, U1.47 (MTDI/JTAG/GPIO41)
/GPIO42: J2.4, U1.48 (MTMS/JTAG/GPIO42)
/GPIO45: J3.19, U1.51 (GPIO45)
/GPIO46: J3.20, U1.52 (GPIO46)
/GPIO47: J2.10, U1.37 (SPICLK_P/GPIO47)
/GPIO48: J2.11, U1.36 (SPICLK_N/GPIO48)
/RST: R9.1, SW3.2, U1.4 (CHIP_PU/RESET)
/SPICLK: R3.1, U3.6 (CLK)
/SPICS0: U1.32 (SPICS0/GPIO29), U3.1 (~CS)
/SPID: R5.1, U3.5 (DI/IO_{0})
/SPIHD: R1.1, U3.7 (~HOLD/~RESET/IO_{3})
/SPIQ: R4.1, U3.2 (DO/IO_{1})
/SPIWP: R2.1, U3.3 (~WP/IO_{2})
/U0RXD: J2.13, U1.50 (U0RXD/PROG/GPIO44)
/U0TXD: J2.12, R6.2
/USB+: J1.A6 (D+), J1.B6 (D+), U1.26 (GPIO20/USB_D+/ADC2_CH9)
/USB-: J1.A7 (D-), J1.B7 (D-), U1.25 (GPIO19/USB_D-/ADC2_CH8)
/XTAL_N: C1.1, U1.53 (XTAL_N), Y1.3
/XTAL_P: C2.1, L1.1, Y1.1
GND: AE2.1, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C15.2, C16.2, C17.2, C18.2, C19.2, D1.1 (K), D3.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.18, J2.19, J2.20, L3.1, R7.2, R8.2, SW1.1, SW3.1, U1.57 (GND), U3.4 (GND), U4.2 (VSS), U4.4 (NC), Y1.2, Y1.4
unnamed: AE2.2, R13.1
unnamed: C10.1, L2.2
unnamed: D3.2 (A), R11.1
unnamed: J1.A5 (CC1), R7.1
unnamed: J1.B5 (CC2), R8.1
unnamed: L3.2, R12.1, R13.2
unnamed: R12.2, U1.1 (LNA_IN/RF)
unnamed: R3.2, U1.33 (SPICLK/GPIO30)
unnamed: R5.2, U1.35 (SPID/GPIO32)
unnamed: R1.2, U1.30 (SPIHD/GPIO27)
unnamed: R4.2, U1.34 (SPIQ/GPIO31)
unnamed: R2.2, U1.31 (SPIWP/GPIO28)
unnamed: R6.1, U1.49 (U0TXD/PROG/GPIO43)
unnamed: L1.2, U1.54 (XTAL_P)
VDD33: C5.1, C6.1, C7.1, C8.1, C9.1, C11.1, C12.1, C15.1, C16.1, C17.1, D1.2 (A), J2.16, J2.17, L2.1, R9.2, R10.2, R11.2, U1.2 (VDD3P3), U1.3 (VDD3P3), U1.20 (VDD3P3_RTC), U1.46 (VDD3P3_CPU), U1.55 (VDDA), U1.56 (VDDA), U4.5 (VOUT)
VDD_SPI: C3.1, C4.1, U1.29 (VDD_SPI), U3.8 (VCC)

Notes on the sheet:
VDDA
VDD3P3
使用内置psram
晶振电路 选择10pf匹配电容的晶振
VDD3P3_CPU
VDD3P3_RTC

Board: 2 copper layers, 45 parts (0 on the bottom side), 63 nets, no tracks yet.

## Commit log

2025-11-29 esp32s3 最小电路
2025-11-29 引出引脚和usb接口的最小板
2025-11-30 修改usb引脚，布局外围电路
